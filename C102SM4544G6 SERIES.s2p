! 6/19/2025 9:40:23 AM
! D:\C102SM4544G6 SERIES.S2P
! CHANNEL.1
! TR.MEASUREMENT
! CORRECTED.DATA
# GHZ S RI R 50.0
! FREQ.GHZ  S11RE  S11IM  S21RE  S21IM  S12RE  S12IM  S22RE  S22IM
!; PortSelection: Port_12
! Worked out from all points (weakly coupled two-port):
!   200 points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, 259.9 MHz to 50 GHz, reference 50 ohm
!   highest |S21| = -14.42 dB at 9.258 GHz (marker M1); lowest = -39.8 dB at 509.9 MHz (marker M2)
!   lowest |S11| = -18.3 dB at 10.01 GHz (marker M3), VSWR 1.28, Z = 50.9 - j12.4 ohm
!   |S11| at or under -10 dB: 9.002 GHz to 11.11 GHz (2.103 GHz wide, 20.9 % of centre)
!   |S22| runs from -9.4 to 0.3 dB; largest |S21 - S12| = 0.042
!   the Smith chart shows 7.259 GHz to 12.51 GHz only
!   S11 on the Smith chart (normalised r, x): 7.259 GHz: 0.32, +0.73; 8.008 GHz: 1.78, +1.48; 8.758 GHz: 1.79, -0.84; 10.51 GHz: 1.06, -0.40; 11.76 GHz: 0.39, -0.12; 12.51 GHz: 0.35, +0.38
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 259.9 MHz  0.1  -31.2  -31.6  0.1
! 509.9 MHz  0.2  -39.8  -40.0  0.1
! 1.01 GHz  -0.6  -23.1  -23.5  -0.6
! 1.26 GHz  0.0  -39.0  -36.5  0.1
! 2.01 GHz  -0.6  -22.8  -22.6  -0.2
! 2.51 GHz  0.0  -31.4  -31.6  0.3
! 3.009 GHz  -0.4  -23.0  -22.0  0.1
! 3.509 GHz  -0.4  -28.1  -28.8  0.0
! 4.009 GHz  -0.5  -20.8  -22.5  -0.2
! 7.259 GHz  -3.6  -18.5  -19.5  -2.6
! 8.008 GHz  -5.5  -16.0  -16.1  -2.7
! 8.758 GHz  -8.0  -16.5  -17.3  -2.2
! 9.258 GHz  -12.6  -14.4  -16.1  -2.0
! 10.01 GHz  -18.3  -15.7  -17.9  -1.5
! 10.51 GHz  -14.4  -17.6  -17.0  -1.4
! 11.76 GHz  -6.9  -17.4  -18.2  -1.3
! 12.51 GHz  -5.5  -19.6  -20.3  -1.4
! 17.01 GHz  -4.2  -24.0  -24.1  -1.6
! 25.25 GHz  -4.3  -22.9  -22.7  -3.1
! 33.5 GHz  -3.5  -27.3  -25.1  -1.7
! 41.75 GHz  -4.4  -20.0  -20.9  -6.2
! 50 GHz  -4.4  -19.4  -18.0  -4.9
